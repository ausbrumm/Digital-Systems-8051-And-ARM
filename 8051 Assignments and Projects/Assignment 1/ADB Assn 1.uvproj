# Keil uVision project ADB Assn 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51CC03 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM (0-0x7FF) CLOCK(33000000) MODP2
  output: ADB Assn 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: AT89C51Assn1.A51
